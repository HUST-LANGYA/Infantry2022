# Keil uVision project HUST-RM-Chassis.uvprojx, settings and files
target HUST-RM-Chassis (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HUST-RM-Chassis
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F10X_CL, USE_STDPERIPH_DRIVER
  c include: ..\User;..\Library\inc;..\Mylib;..\Algorithm;..\Task;..\FreeRTOS\include;..\FreeRTOS\port\MemMang;..\FreeRTOS\port\RVDS\ARM_CM3;..\Project
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c system_stm32f10x.c stm32f10x_it.c startup_stm32f10x_cl.s
  group Library
    ../Library/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Mylib
    ../Mylib/: can1.c can2.c usart2.c tim2.c tim4.c ina260.c adc.c i2c.c dac.c iwdg.c uart4.c
  group Algorithm
    ../Algorithm/: FIR.c pid.c DataScope_DP.C algorithmOfCRC.c
  group Task
    ../Task/: DataReceiveTask.c DataSendTask.c ChassisTask.c PowerControlTask.c StartTask.c CharSendTask.c GraphicsSendTask.c
    ./: JumpCal_Task.c
  group FreeRTOS/Src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/Ports
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM3/: port.c
